# Keil uVision project spms_disp.uvprojx, settings and files
target Target 1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F429IITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.10.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: spms_disp +hex
  AfterMake: H:\智能电源监控系统\spms_disp\project\DelTempFile_CopyHex.bat
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\sourcecode;..\sourcecode\User;..\sourcecode\User\fonts;..\sourcecode\User\fatfs;..\sourcecode\User\fatfs\src;..\sourcecode\User\fatfs\src\option;..\sourcecode\User\bsp;..\sourcecode\User\bsp\inc;..\sourcecode\Libraries\CMSIS\Include;..\sourcecode\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\sourcecode\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\sourcecode\FreeRTOS\include;..\sourcecode\FreeRTOS\portable\MemMang;..\sourcecode\FreeRTOS\portable\RVDS\ARM_CM4F;..\sourcecode\emWin\Config;..\sourcecode\emWin\emWinTask;..\sourcecode\emWin\Include;..\sourcecode\emWin\GUI_X
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Main
    ../sourcecode/User/: main.c SysInfoTest.c FreeRTOSConfig.h includes.h
  group Startup
    ../sourcecode/Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f429_439xx.s
  group Bsp_Drivers
    ../sourcecode/User/bsp/src/: param.c TOUCH_STMPE811.c bsp_ts_ft5x06.c bsp_touch.c bsp_tim_pwm.c bsp_tft_lcd.c bsp_tft_429.c bsp_gt811.c bsp_led.c bsp_key.c bsp_dwt.c bsp_ext_io.c bsp_uart_fifo.c bsp_fmc_sdram.c
    ../sourcecode/User/bsp/: bsp.c bsp.h stm32f4xx_it.c stm32f4xx_assert.c
  group StdPeriph_Driver
    ../sourcecode/User/bsp/: system_stm32f4xx.c
    ../sourcecode/Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_wwdg.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_syscfg.c stm32f4xx_rtc.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_gpio.c stm32f4xx_fmc.c stm32f4xx_flash.c stm32f4xx_exti.c stm32f4xx_dma2d.c stm32f4xx_dma.c
  group Front
    ../sourcecode/User/fonts/: asc12.c asc16.c hz12.c hz16.c hz24.c hz32.c ra8875_asc_width.c
  group STemWin
    ../sourcecode/emWin/GUILib/: STemWin532_CM4_OS_Keil_ot.lib
    ../sourcecode/emWin/emWinTask/: App_ScaleWin.c App_SysFunction.c MainTask.c
    ../sourcecode/emWin/Config/: GUIConf.c GUIConf.h LCDConf_Lin_Template.c LCDConf_Lin_Template.h
    ../sourcecode/emWin/GUI_X/: GUI_X_FreeRTOS.c
  group FreeRTOS
    ../sourcecode/FreeRTOS/portable/RVDS/ARM_CM4F/: port.c portmacro.h
    ../sourcecode/FreeRTOS/portable/MemMang/: heap_4.c
    ../sourcecode/FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FatFS
    ../sourcecode/User/fatfs/src/: diskio.c ff.c diskio.h ff.h ffconf.h integer.h
